# Keil uVision project GPIO.uvproj, settings and files
target S8pannel (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\wifi;.\Code
  group Main
    ./Code/: GPIO.C customtimer.c step.c draw.c coordinate.c H595.C
  group Common
    ./Common/: Common.c
  group Startup
    ./Startup/: STARTUP.A51
